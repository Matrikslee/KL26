# Keil uVision project newKL26.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.0.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: newKL26
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\src\DEV;.\src\DRI;.\src\SYS;.\src\USR
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group DEV
    ./src/DEV/: accel.c crc.c isr.c led.c pwm.c
  group DRI
    ./src/DRI/: adc.c delay.c dma.c gpio.c i2c.c pit.c spi.c sys.c TPM.c uart.c counter.c
  group SYS
    ./src/SYS/: system_MKL25Z4.c startup_MKL25Z4.s
  group USR
    ./src/USR/: app.c main.c user.c
