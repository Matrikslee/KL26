# Keil uVision project MKL.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.0.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x3000) IRAM2(0x1FFFF000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MKL +hex
  c flags: Optim=1
  c include: .\DEV;.\DRI;.\SYS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x1ffff000 size 0x1000
  group SYS
    ./SYS/: system_MKL25Z4.c startup_MKL25Z4.s
  group DEV
    ./DEV/: accel.c led.c crc.c isr.c
  group DRI
    ./DRI/: adc.c dma.c gpio.c i2c.c pit.c spi.c sys.c uart.c delay.c TPM.c
  group USR
    ./USR/: user.c main.c app.c
